/*==========================================Copyright(c)=======================================
**                                  Shenzhen Infypower Co., Ltd.
**                                  Power conversion Department
**                                       BMS Product Line
**
**---------------------------------------File Information--------------------------------------
** @File Name    : BSPIRQ.c
** @Founder      : WYC834
** @Date         : 2025.08.21
** @Function     : 临界区驱动函数模块
** @Instructions :
**===========================================================================================*/

/*=============================================================================================
** @Header file definition
**===========================================================================================*/
#include "main.h"
#include "BSPTypeDef.h"
#include "BSPIRQ.h"
#include "cmsis_os.h"
/*=============================================================================================
** @Global variable definition
**===========================================================================================*/
static u16 sInterruptNum = 0;

/*=============================================================================================
** @Static function declaration
**===========================================================================================*/

/*=============================================================================================
** @Interface function definition
**===========================================================================================*/
/*=============================================================================================
** @Name      : void BSP_DISABLE_IRQ(void)
** @Input     : void
** @Output    : void
** @Function  : 禁止中断
** @The notes :
**===========================================================================================*/
void BSP_DISABLE_IRQ(void)
{
    if(sInterruptNum == 0) 
    {
        taskENTER_CRITICAL();//进入临界区，关闭中断，关闭调度器
    }
    
    sInterruptNum++;
}

/*=============================================================================================
** @Name      : void BSP_ENABLE_IRQ(void)
** @Input     : void
** @Output    : void
** @Function  : 使能中断
** @The notes :
**===========================================================================================*/
void BSP_ENABLE_IRQ(void)
{
    if (sInterruptNum == 0)
    {
        return;
    }
    
   if((sInterruptNum == 1))
    {
        taskEXIT_CRITICAL();//启用中断，退出临界区
        sInterruptNum = 0;
    }
    else
    {
        sInterruptNum--;
    }
}
