# IAR project IMIU4.ewp, settings and files
configuration IMIU4 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G0B1RC ST STM32G0B1RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32G0B1xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc; ../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0; ../Drivers/CMSIS/Device/ST/STM32G0xx/Include; ../Drivers/CMSIS/Include; ..\Application\Addition\RTT; ..\Application\BSPSys\BSPCfg; ..\Application\BSPSys\Util; ..\Application\BSPSys\BSPDriver; ..\Application\Addition\Crc; ..\Application\BSPSys\BSPDevice\gd25q32e; ..\Application\BSPSys\BSPDevice\KA84917; ..\Application\BSPSys\BSPUser; ..\Application\OSTasks; ..\Application\BSPSys\BSPDevice\rn8209; ..\Application\Funtion\SystemData; ..\Application\Funtion\Measure; ..\Application\Logics\Insulation; ..\Application\Funtion\SystemPara; ..\Application\Funtion\SystemDiag; ..\Application\Funtion\Usart; ..\Application\Funtion\SystemInfo; ..\Application\Funtion\CanLib; ..\Application\Funtion\SystemDebug; ..\Application\BSPSys\BSPDevice\eeprom; ..\Application\Funtion\DoControl; ..\..\..\..\IMIU4-toolingcheck_update\Application\Funtion\Usart; ..\Application\Addition\UDSCanfd; ..\Application\Addition\UDSCanfd\network_layer; ..\Application\Addition\UDSCanfd\services_layer; ..\Application\Addition\UDSCanfd\services_layer\device_role; ..\Core\Inc; ..\Application\Funtion\LoadApp; ..\Application\Addition\cm_backtrace; ..\Application\Addition\cm_backtrace\Languages; ..\Application\Addition\cm_backtrace\fault_handler; ..\Application\Addition\Modbus; ..\Application\Addition\cm_backtrace; ..\Application\Funtion\Test
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../Core/Inc
  OBJCOPY.OOCOutputFile: IMIU4.hex
  ILINK.IlinkOutputFile: IMIU4.out
  ILINK.IlinkIcfFile: stm32g0b1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Additon/cm_backtrace
    ../Application/Addition/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
  group Application/Additon/cm_backtrace/fault_handler/iar
    ../Application/Addition/cm_backtrace/fault_handler/iar/: cmb_fault.S
  group Application/Additon/cm_backtrace/Languages/en-US
    ../Application/Addition/cm_backtrace/Languages/en-US/: cmb_en_US.h
  group Application/Additon/cm_backtrace/Languages/zh-CN
    ../Application/Addition/cm_backtrace/Languages/zh-CN/: cmb_zh_CN.h cmb_zh_CN_UTF8.h
  group Application/Additon/Crc
    ../Application/Addition/Crc/: crc.c crc.h
  group Application/Additon/Modbus
    ../Application/Addition/Modbus/: Modbus.c Modbus.h
  group Application/Additon/Rtt
    ../Application/Addition/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group Application/Additon/UDSCanfd
    ../Application/Addition/UDSCanfd/: api_for_application.c api_for_application.h can_uds_arch.c can_uds_arch.h can_uds_interface.c can_uds_interface.h
  group Application/Additon/UDSCanfd/nerwork_layer
    ../Application/Addition/UDSCanfd/network_layer/: can_uds_network_layer.c can_uds_network_layer.h
  group Application/Additon/UDSCanfd/services_layer/device_role
    ../Application/Addition/UDSCanfd/services_layer/device_role/: can_uds_services_layer.c can_uds_services_layer.h sid10_diagnostic_session_ctrl.c sid11_ecu_reset.c sid22_read_data_by_id.c sid27_security_access.c sid28_communication_ctrl.c sid2e_write_data_by_id.c sid31_routine_ctrl.c sid34_request_download.c sid36_transfer_data.c sid37_transfer_exit.c sid3e_tester_present.c sid_internal_header.h
  group Application/BSPSys/BSPCfg
    ../Application/BSPSys/BSPCfg/: BSPConfig.c BSPConfig.h
  group Application/BSPSys/BSPDevice/eeprom
    ../Application/BSPSys/BSPDevice/eeprom/: EEPROM.c EEPROM.h
  group Application/BSPSys/BSPDevice/gd25q
    ../Application/BSPSys/BSPDevice/gd25q32e/: BSPGD25Q32E.c BSPGD25Q32E.h
  group Application/BSPSys/BSPDevice/KA84917
    ../Application/BSPSys/BSPDevice/KA84917/: BSPKA84917_async.c BSPKA84917_async.h spi_async.c spi_async.h
  group Application/BSPSys/BSPDevice/RN8209
    ../Application/BSPSys/BSPDevice/rn8209/: drv_rn8209.c drv_rn8209.h drv_rn8209_interface.h drv_rn8209_type.h
  group Application/BSPSys/BSPDrive
    ../Application/BSPSys/BSPDriver/: BSPADC.c BSPADC.h BSPCAN.c BSPCAN.h BSPDIDO.c BSPDIDO.h BSPDMA.c BSPDMA.h BSPFLASH.c BSPFLASH.h BSPGPIO.c BSPGPIO.h BSPIIC.c BSPIIC.h BSPIRQ.c BSPIRQ.h BSPMCG.c BSPMCG.h BSPSPI.c BSPSPI.h BSPTIM.c BSPTIM.h BSPUSART.c BSPUSART.h BSPWDOG.c BSPWDOG.h
  group Application/BSPSys/BSPUser
    ../Application/BSPSys/BSPUser/: BSPUserHook.c BSPUserHook.h
  group Application/BSPSys/Util
    ../Application/BSPSys/Util/: BSPQueue.c BSPQueue.h BSPTypeDef.h
  group Application/EWARM
    ./: startup_stm32g0b1xx.s
  group Application/Funtion/CanLib
    ../Application/Funtion/CanLib/: CANHandle.c CANHandle.h CANInterface.c CANInterface.h CANTabOper.c CANTabOper.h CANTxCycle.c CANTxCycle.h CANUser.c CANUser.h
  group Application/Funtion/DoControl
    ../Application/Funtion/DoControl/: DoControl.c DoControl.h
  group Application/Funtion/LoadAPP
    ../Application/Funtion/LoadApp/: LoadApp.c LoadApp.h
  group Application/Funtion/Measure
    ../Application/Funtion/Measure/: CurrFliterCalc.c CurrFliterCalc.h Measure.c Measure.h
  group Application/Funtion/SystemData
    ../Application/Funtion/SystemData/: SystemData.c SystemData.h
  group Application/Funtion/SystemDebug
    ../Application/Funtion/SystemDebug/: SystemDebug.c SystemDebug.h
  group Application/Funtion/SystemDiag
    ../Application/Funtion/SystemDiag/: SystemDiag.c SystemDiag.h
  group Application/Funtion/SystemInfo
    ../Application/Funtion/SystemInfo/: SystemInfo.c SystemInfo.h
  group Application/Funtion/SystemPara
    ../Application/Funtion/SystemPara/: SystemPara.c SystemPara.h
  group Application/Funtion/Test
    ../Application/Funtion/Test/: TEST.c TEST.h
  group Application/Funtion/Usart
    ../Application/Funtion/Usart/: Calibration.c Calibration.h ToolingCheck.c ToolingCheck.h UsartHandle.c UsartHandle.h
  group Application/Logics/Insulation
    ../Application/Logics/Insulation/: Insulation.c Insulation.h
  group Application/OSTasks
    ../Application/OSTasks/: OSUserTasks.c OSUserTasks.h
  group Application/User/Core
    ../Core/Src/: adc.c app_freertos.c dma.c fdcan.c gpio.c i2c.c iwdg.c main.c spi.c stm32g0xx_hal_msp.c stm32g0xx_hal_timebase_tim.c stm32g0xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_ll_adc.c stm32g0xx_ll_dma.c stm32g0xx_ll_rcc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s
