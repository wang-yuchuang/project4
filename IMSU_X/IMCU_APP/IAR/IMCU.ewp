# IAR project IMCU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; USE_HAL_DRIVER; STM32F407xx; USE_USB_FS
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; ..\BSP; ..\BSP\ST; ..\BSP\Include; ..\uCOS-II\CPU; ..\uCOS-II\LIB; ..\uCOS-II\OS\Source; ..\uCOS-II\OS\Ports; ..\uCOS-II\Serial\ST; ..\uCOS-II\Serial\Line; ..\uCOS-II\Serial\OS; ..\uCOS-II\Serial\Source; ..\App; ..\App\uCOS; ..\BSP\ST\STM32F4xx_HAL_Driver\; ..\BSP\ST\STM32F4xx_HAL_Driver\inc; ..\BSP\HAL; ..\App\codes\drivers; ..\App\codes\ETH\ethapp; ..\App\codes\ETH\ethapp\snmpserver; ..\App\codes\ETH\ethapp\dhcpc; ..\uip; ..\App\codes\ETH\ethapp\webserver; ..\App\codes; ..\App\codes\NET; ..\App\codes\Lwip213\include\lwip; ..\App\codes\ETH\ethappLwip; ..\App\codes\RTT; ..\SEGGER_RTT_V780\RTT\\; ..\App\codes\MQTT; ..\App\codes\secondary_upgrade; ..\BSP\STM32_USB_Host_Library; ..\App\codes\protobuf; ..\App\codes\imeu2_upgrade; ..\BSP\STM32_USB_Host_Library\Core\Inc; ..\BSP\STM32_USB_Host_Library\Class\MSC\Inc; ..\BSP\FatFs\src; ..\cm_backtrace; ..\SEGGER_RTT_V780\Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IMSU_X.bin
  ILINK.IlinkOutputFile: IMCU.out
  ILINK.IlinkIcfFile: ..\BSP\STM32F4xx_FLASH_Offset.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
configuration HAL_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; $PROJ_DIR$; ..\; ..\BSP; ..\BSP\ST; ..\BSP\Include; ..\BSP\FatFs; ..\BSP\STM32_USB_Host_Library; ..\BSP\STM32_USB_Host_Library\Core\Inc; ..\BSP\STM32_USB_Host_Library\Class\MSC\Inc; ..\BSP\FatFs\src; ..\BSP\FatFs\src\drivers; ..\uCOS-II\CPU; ..\uCOS-II\LIB; ..\uCOS-II\OS\Source; ..\uCOS-II\OS\Ports; ..\uCOS-II\Serial\ST; ..\uCOS-II\Serial\Line; ..\uCOS-II\Serial\OS; ..\uCOS-II\Serial\Source; ..\App; ..\App\uCOS; ..\BSP\ST\STM32F4xx_HAL_Driver\; ..\BSP\ST\STM32F4xx_HAL_Driver\inc; ..\BSP\HAL; ..\App\codes\drivers; ..\App\codes\ETH\ethapp; ..\App\codes; ..\config; ..\..\..\..\3_change\A2418_Liquid_ESPCU_SRC_V100\IMCU_APP\App\codes; ..\App; ..\App\codes; ..\App\codes\drivers; ..\App\codes\ETH; ..\App\codes\ETH\ethapp; ..\App\codes\ETH\ethapp\dhcpc; ..\App\codes\ETH\ethapp\snmpserver; ..\App\codes\ETH\ethapp\snmpserver\snmpmib; ..\App\codes\ETH\ethapp\webserver; ..\App\codes\imeu2_upgrade; ..\App\codes\MQTT; ..\App\codes\protobuf; ..\App\codes\secondary_upgrade; ..\uip; ..\SEGGER_RTT_V780\Config; ..\SEGGER_RTT_V780\RTT; ..\BSP\ST; ..\BSP\ST\STM32F4xx_HAL_Driver; ..\BSP\ST\STM32F4xx_HAL_Driver\Inc; ..\BSP\ST\STM32F4xx_HAL_Driver\Src; ..\cm_backtrace; ..\cm_backtrace\fault_handler\iar; ..\cm_backtrace\Languages\en-US; ..\cm_backtrace\Languages\zh-CN
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: IMCU.bin
  ILINK.IlinkIcfFile: ..\BSP\STM32F4xx_FLASH.icf
configuration STD_Debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: DRAFT1.srec
  ILINK.IlinkOutputFile: M530SV01.out
  ILINK.IlinkIcfFile: ..\BSP\STM32F4xx_FLASH.icf
configuration txydebug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; ..\BSP; ..\BSP\ST; ..\BSP\Include; ..\uCOS-II\CPU; ..\uCOS-II\LIB; ..\uCOS-II\OS\Source; ..\uCOS-II\OS\Ports; ..\uCOS-II\Serial\ST; ..\uCOS-II\Serial\Line; ..\uCOS-II\Serial\OS; ..\uCOS-II\Serial\Source; ..\App; ..\App\uCOS; ..\BSP\ST\STM32F4xx_HAL_Driver\; ..\BSP\ST\STM32F4xx_HAL_Driver\inc; ..\BSP\HAL; ..\MiddleWare\STM32_USB_Host_Library; ..\MiddleWare\STM32_USB_Host_Library\Core\Inc; ..\MiddleWare\STM32_USB_Host_Library\Class\MSC\Inc; ..\MiddleWare\FatFs\src; ..\MiddleWare\FatFs\src\drivers; ..\App\Codes\comm; ..\App\codes\drivers; ..\App\codes\comm\ethapp; ..\App\codes\comm\ethapp\snmpserver; ..\App\codes\comm\ethapp\webserver; ..\Middleware\LwIP\src\include\; ..\Middleware\LwIP\src\include\ipv4; ..\Middleware\LwIP\system
  OBJCOPY.OOCOutputFile: M530S.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  group App
    ../App/: main.c main.h
  group App/codes
    ../App/codes/: ABU.c ABU.h ALM.c base_def.h CAN1.c CAN2.c CAN3.c CAN3_Tx_Task.c can_ring.h DCLeakageCurrentSensor.c DCLeakageCurrentSensor.h E2PRom.c EnergyOutputMng.h EnergyOutputMng_Ring.c EtherNet.c EtherNet.h FAN.c Flash.c IMEU2.c IMIU.c IMMU2_LCCU.c LCD.c LCD.h Measure.c MQTTClient.c MQTTClient.h PowerModuleAction.c PowerModuleUpgrade.c ring_main.c RTC.c SelfTest.c Test.c Uart1.c Uart2.c Uart4.c Uart5.c Uart6.c Uart6_GetSigValue.c Uart6_new.h Uart6_ScreemEventDeal.c Upgrade.c Upgrade.h usb.c WH_Meter.c
  group App/codes/drivers
    ../App/codes/drivers/: device.c ethdev.c ethdev.h History.h HistoryEvent.c HistoryEvent.h hz.h init1.c init1.h interface.c interface.h LCDDriver.c mutex.c mutex.h setdata.c setdata.h
  group App/codes/ETH
    ../App/codes/ETH/: ethcomm.c
  group App/codes/ETH/ethapp
    ../App/codes/ETH/ethapp/: clock-arch.c clock-arch.h resolv.c resolv.h snmp.c uip_app_router.c uip_app_router.h
  group App/codes/ETH/ethapp/dhcpc
    ../App/codes/ETH/ethapp/dhcpc/: dhcpc.c dhcpc.h
  group App/codes/ETH/ethapp/snmpserver
    ../App/codes/ETH/ethapp/snmpserver/: a1rwint.c a1rwlen.c a1rwoid.c a1rwval.c asn1.h kernel.h mib.h mibtrap.h mksnmp.c sna2b.c snb2a.c snfreebl.c snhash.c snhash.h snleaf.c snmib.c snmp.h snparse.c snrslv.c sntrap.c sntrapmib.c vssver.scc
  group App/codes/ETH/ethapp/snmpserver/snmpmib
    ../App/codes/ETH/ethapp/snmpserver/snmpmib/: vssver.scc
  group App/codes/ETH/ethapp/webserver
    ../App/codes/ETH/ethapp/webserver/: http-strings.c http-strings.h http_download.c Http_download.h httpd-cgi.c httpd-cgi.h httpd-fs.c httpd-fs.h httpd-fsdata.c httpd-fsdata.h httpd.c httpd.h
  group App/codes/imeu2_upgrade
    ../App/codes/imeu2_upgrade/: imeu2_upgrade.c imeu2_upgrade.h
  group App/codes/MQTT
    ../App/codes/MQTT/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group App/codes/protobuf
    ../App/codes/protobuf/: pb.h pb_common.c pb_common.h pb_decode.c pb_decode.h pb_encode.c pb_encode.h simple.c simple.pb.c simple.pb.h Telaidian.pb.c Telaidian.pb.h TelaidianProto.c TelaidianProto.h
  group App/codes/secondary_upgrade
    ../App/codes/secondary_upgrade/: secondary_upgrade.c secondary_upgrade.h
  group App/uCOS
    ../App/uCOS/: app_cfg.h app_hooks.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group BSP
    ../BSP/: bsp.c bsp.h bsp_IRQ.c bsp_os.c bsp_os.h bsp_periph.c cstartup.c STM32F4xx_FLASH.icf
  group BSP/FatFs
    ../BSP/FatFs/src/: diskio.c fatfs.c ff.c ff_gen_drv.c
    ../BSP/FatFs/src/option/: syscall.c
    ../BSP/FatFs/src/drivers/: usbh_diskio.c
  group BSP/Include
    ../BSP/Include/: base_def.h bsp_adc.h bsp_can.h bsp_capture.h bsp_dido.h bsp_eeprom.h bsp_fsmc.h bsp_pwm.h bsp_SPI.h bsp_uart.h bsp_usb.h stm32f4xx_hal_conf.h stm32f4xx_it.h usbh_conf.h
  group BSP/Source
    ../BSP/Source/: bsp_adc.c bsp_can.c bsp_capture.c bsp_dido.c bsp_eeprom.c bsp_fsmc.c bsp_pwm.c bsp_SPI.c bsp_uart.c bsp_usb.c file_operations.c iap_menu.c stm32f4xx_it.c system_stm32f4xx.c usbh_conf.c
  group BSP/ST/STM32F4xx_HAL_Driver
    ../BSP/ST/STM32F4xx_HAL_Driver/: stm32f407xx.h stm32f4xx.h stm32f4xx_hal_conf.h stm32f4xx_hal_confm530s.h system_stm32f4xx.h
  group BSP/ST/STM32F4xx_HAL_Driver/inc
    ../BSP/ST/STM32F4xx_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_adc_ex.h stm32f4xx_hal_can.h stm32f4xx_hal_conf_template.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_usb.h
  group BSP/ST/STM32F4xx_HAL_Driver/src
    ../BSP/ST/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_msp.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c
  group BSP/STM32_USB_Host_Library/class/MSC
    ../BSP/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group BSP/STM32_USB_Host_Library/core
    ../BSP/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group config
    ../config/: dbconfig.h ESPCU_dbstd.def
  group SEGGER_RTT_V780/Config
    ../SEGGER_RTT_V780/Config/: SEGGER_RTT_Conf.h
  group SEGGER_RTT_V780/RTT
    ../SEGGER_RTT_V780/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c
  group uCOS-II/CPU
    ../uCOS-II/CPU/: cpu.h cpu_a.asm cpu_c.c cpu_core.c cpu_core.h cpu_def.h
  group uCOS-II/LIB
    ../uCOS-II/LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_mem_a.asm lib_str.c lib_str.h
  group uCOS-II/OS/Ports
    ../uCOS-II/OS/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group uCOS-II/OS/Source
    ../uCOS-II/OS/Source/: os.h os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group uip
    ../uip/: clock.h lc-addrlabels.h lc-switch.h lc.h psock.c psock.h pt.h timer.c timer.h uip-conf.h uip-fw.c uip-fw.h uip-neighbor.c uip-neighbor.h uip-split.c uip-split.h uip.c uip.h uip_arch.h uip_arp.c uip_arp.h uiplib.c uiplib.h uipopt.h vssver.scc
